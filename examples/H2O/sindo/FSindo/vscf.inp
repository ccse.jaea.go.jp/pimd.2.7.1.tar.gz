#--- [  INPUT PARAMETER  ]
 &mol minfofile='nma.minfo' /
 &sys maxmem=10 /

#--- [  VIB  ]
 &vib  
  MR=3 
  vmaxAll=10 
  vscf=.t. 
 /

#--- [ TARGET STATES ]
 &states
  fund=.t.
 /

#--- [  VSCF  ]
 &vscf 
  Maxitr=200
  Ethresh=1.D-03 
 / 
