#--- [  INPUT PARAMETER  ]
 &mol minfofile='nma.minfo' /
 &sys maxmem=10 /

#--- [  VIB  ]
 &vib  
  MR=3 
  vmaxAll=10 
  vscf=.t. 
  vci=.t. 
 /

#--- [  VCI  ]
 &vci 
  nstate=20 
  nCUP=3 
  maxSum=8 
 /

#--- [  VSCF  ]
 &vscf 
  Maxitr=200
  Ethresh=1.D-03 
 / 
